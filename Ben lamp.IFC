Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView]
File name: Z:\DESIGN\09 BEN LAMP\3D Model\Concept 2\2023.01.17\Other formats\Ben lamp.IFC
Time: 2024-08-06T19:19:31+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC2X3

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 7.8252280331715545; Volume Measure: 0.0047854831837679; Area Measure: 0.8999369586925934

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 7.8252280331715545; Volume Measure: 0.0047854831837679; Area Measure: 0.8999369586925934

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 7.8252280331715545; Volume Measure: 0.0047854831837679; Area Measure: 0.8999369586925934

# IfcBuildingElementProxy (10)
In: default BuildingStorey
Name
Ben lamp 2023.01.162023.01.17 | PSet_Mass_Property - Mass Measure: 7.8252280331715545; Volume Measure: 0.0047854831837679; Area Measure: 0.8999369586925934
M12x1.0mm Pitch to M14x1.0pitch
M10x1.0mm Pitch to M12x1.0pitch
M12 1mm Pitch
Base 2023.01.17
G9 Hardware
Globe 22023.01.17
Body 2023.01.17
4391N114_Fine-Thread High-Strength Zinc-Plated Steel Hex Nut | SOLIDWORKS Custom Properties - PartNo: 4391N114; Description: Fine-Thread High-Strength Zinc-Plated Steel Hex Nut; Material: Steel; Vendor: McMaster-Carr Supply Company; Copyright: © 2021 McMaster-Carr Supply Company; CAD Model Disclaimer and Terms of Use: https://www.mcmaster.com/terms; Desc1: Fine-Thread High-Strength; Desc2: Zinc-Plated Steel Hex Nut; Desc3: © 2021 McMaster-Carr Supply Company; sets with these values: 2
M12x1.0mm Pitch to M14x1.0pitch-1
